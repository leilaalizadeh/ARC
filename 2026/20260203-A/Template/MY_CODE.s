NUMBER		RN 0
CNT			RN 1
TMP			RN 2
TMP1		RN 3
COUNT		RN 4
PREV		RN 5
RESULT		RN 6
MASK		RN 7
CNT1		RN 8
TMP2		RN 10
MASK1		RN 11
			AREA MY_CODE,CODE, READONLY
Look_and_Say 	PROC
			EXPORT Look_and_Say
			PUSH{R4-R8,R10-R11,LR}
	        LDR CNT,=0
			LDR CNT1,=1               ;EDITED: CHANGE CNT1 VALUE FROM 0 TO 1
			LDR COUNT,=0
			LDR PREV,=0
			LDR RESULT,=0
FOR
			LDR TMP,=10
			UDIV TMP1,NUMBER,TMP  
			ORR MASK,TMP1,NUMBER      ;EDITED: ADD - TO CHECK IF THE QUOTIENT, THE NUMBER, AND THE REMAINDER ARE ALL ZERO IN ORDER TO FINISH THE LOOP
			ORR MASK,MASK,TMP2        ;EDITED: ADD - TO CHECK IF THE QUOTIENT, THE NUMBER, AND THE REMAINDER ARE ALL ZERO IN ORDER TO FINISH THE LOOP
			CMP MASK,#0               ;EDITED: CHNAGE TMP1 TO MASK
			BEQ FINISH   
			MUL TMP,TMP1
			SUB	TMP2,NUMBER,TMP  
			MOV NUMBER,TMP1
			CMP CNT,#0
			ITTE  EQ
			MOVEQ PREV,TMP2
			ADDEQ COUNT,#1
			BNE	NOT_ZERO
			B NEXT
NOT_ZERO
			CMP PREV,TMP2
			BEQ	CHECK_PREV
			LDR MASK,=10       ; EDITED: CHANGE PLACE
;			CMP CNT1,#0        ; EDITED: REMOVE 
;			IT	EQ             ; EDITED: REMOVE 
;			LDREQ MASK,=10     ; EDITED: CHANGE PLACE
;			MULNE MASK,MASK1   ; EDITED: REMOVE 
			MUL COUNT,MASK
			ADD COUNT,PREV     
		    MUL COUNT,CNT1     ; EDITED: ADD -  (1 * 39 , 100 * 18 , 10000 * 26 , 1000000 * 13)
			ADD RESULT,COUNT   
			;ADD CNT1,#2       ; EDITED: REMOVE
			LDR MASK1,=100     ; EDITED: CHANGE PLACE
			MUL CNT1,MASK1     ; EDITED: ADD - EACH TIME CNT1 MULTIPLY BY 100
			LDR COUNT,=0
			MOV PREV,TMP2  
CHECK_PREV
			ADD COUNT,#1
			B NEXT
NEXT		
			ADD CNT,#1
			B FOR
FINISH
			MOV R0,RESULT
	        POP{R4-R8,R10-R11,PC}
			ENDP
			END
				
					
	