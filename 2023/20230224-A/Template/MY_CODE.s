A				    RN 0
CNT				    RN 1
TMP				    RN 2
TMP1			    RN 3
TMP2                RN 4
FIRST_VAL			RN 5
SECOND_VAL			RN 6
THIRD_VAL			RN 7
FORTH_VAL			RN 8
A_COPY			    RN 9
REUSLT				RN 10

				AREA MY_CODE, CODE, READONLY
					
KaprekarRoutine1  PROC
	             EXPORT KaprekarRoutine1
				 PUSH{R4-R8,R10-R11,LR}
				 LDR CNT,=0
				 MOV A_COPY,A
FOR
				 CMP  CNT,#4
				 BEQ  SETP_2
				 LDR  TMP,=10
				 UDIV TMP1,A_COPY,TMP   ; Q = A/10
				 MUL  TMP2,TMP1,TMP     ; M * 10
				 SUB  TMP2,A_COPY,TMP2  ; REMAINDER =  A - (M*10)
				 MOV  A_COPY,TMP1
				 CMP  CNT,#0
				 BEQ  FIRST
				 CMP  CNT,#1
				 BEQ  SECOND
				 CMP  CNT,#2
				 BEQ  THIRD
				 CMP  CNT,#3
				 BEQ  FORTH
FIRST
				 MOV  FIRST_VAL, TMP2    ; MOVE FIRST DIGIT TO THE RESULT 
				 B    NEXT
SECOND
				 CMP   TMP2,FIRST_VAL           ; CHECK FIRST DIGIT WITH SECOND DIGIT 
				 ITTE  HI
				 MOVHI SECOND_VAL, FIRST_VAL
				 MOVHI FIRST_VAL,TMP2
				 MOVLS SECOND_VAL,TMP2
				 B     NEXT		
THIRD
				 CMP   TMP2,SECOND_VAL          ; CHECK SECOND DIGIT WITH THIRD DIGIT 
				 ITTE  HI
				 MOVHI THIRD_VAL,SECOND_VAL
				 MOVHI SECOND_VAL,TMP2
				 MOVLS THIRD_VAL,TMP2
				 CMP   SECOND_VAL,FIRST_VAL        ; CHECK FIRST DIGIT WITH SECOND DIGIT 
				 ITTT  HI
				 MOVHI TMP2,SECOND_VAL
				 MOVHI SECOND_VAL,FIRST_VAL
				 MOVHI FIRST_VAL,TMP2
				 B     NEXT
FORTH 
				 CMP   TMP2,THIRD_VAL
				 ITTE  HI
				 MOVHI FORTH_VAL, THIRD_VAL
				 MOVHI THIRD_VAL,TMP2
				 MOVLS FORTH_VAL,TMP2
				 CMP   THIRD_VAL,SECOND_VAL
				 ITTT  HI
				 MOVHI TMP2,THIRD_VAL
				 MOVHI THIRD_VAL,SECOND_VAL
				 MOVHI SECOND_VAL,TMP2
				 CMP   SECOND_VAL,FIRST_VAL
				 ITTT  HI
				 MOVHI TMP2,SECOND_VAL
				 MOVHI SECOND_VAL,FIRST_VAL
				 MOVHI FIRST_VAL,TMP2
				 B     NEXT
NEXT				 
				 ADD CNT,#1
				 B FOR 
SETP_2
				 LDR REUSLT,=10
				 MUL TMP,FIRST_VAL,REUSLT    ; 70
				 ADD TMP,TMP,SECOND_VAL	     ; 75
				 MUL TMP,TMP,REUSLT          ; 750
				 ADD TMP,TMP,THIRD_VAL	     ; 753
                 MUL TMP,TMP,REUSLT          ; 7530
				 ADD TMP,TMP,FORTH_VAL	     ; 7530	
				 B STEP_3
STEP_3
				 MUL TMP1,FORTH_VAL,REUSLT    ; 0
				 ADD TMP1,TMP1,THIRD_VAL	  ; 3
				 MUL TMP1,TMP1,REUSLT         ; 30
				 ADD TMP1,TMP1,SECOND_VAL	  ; 35
                 MUL TMP1,TMP1,REUSLT         ; 350
				 ADD TMP1,TMP1,FIRST_VAL	  ; 357
				 B   STEP_4		
STEP_4

				 SUB TMP2,TMP,TMP1
				 MOV R0,TMP2
				 POP{R4-R8,R10-R11,PC}
				 ENDP
				 END