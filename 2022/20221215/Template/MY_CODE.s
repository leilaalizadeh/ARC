X			RN 0
Y			RN 1
MANTISSAX	RN 2
MANTISSAY	RN 3
EXPONENTX	RN 4
EXPONENTY	RN 5
CNT			RN 6
CNT1		RN 7
TMP			RN 8
TMP1		RN 10
ONE			RN 11
			
			AREA MY_CODE,CODE, READONLY
				
addFPpositiveNumbers	PROC
			EXPORT addFPpositiveNumbers
			PUSH{R4-R8,R10-R11,LR}
			
			LDR CNT,=0
			LDR CNT1,=0
LOOP
			CMP CNT,#31
			BEQ STEP2
			CMP CNT,#23
			BLO	MANTISSA
			BHS EXPONENT
			
MANTISSA
			LSR TMP,X,CNT
			AND TMP,#1
			LSL TMP,CNT
			ORR MANTISSAX,TMP
			
			LSR TMP,Y,CNT
			AND TMP,#1
			LSL TMP,CNT
			ORR MANTISSAY,TMP
			
			B NEXT

EXPONENT
			LSR TMP,X,CNT
			AND TMP,#1
			LSL TMP,CNT1
			ORR EXPONENTX,TMP
			
			LSR TMP,Y,CNT
			AND TMP,#1
			LSL TMP,CNT1
			ORR EXPONENTY,TMP
			
			ADD CNT1,#1
			
			B NEXT

NEXT 
			ADD CNT,#1
			B LOOP

STEP2
			LDR ONE,=1
			LSL ONE,#23
			ORR MANTISSAX,ONE
			ORR MANTISSAY,ONE 
			
			CMP EXPONENTX,EXPONENTY
			BEQ EQUAL
			BNE NOT_EQUAL
			
EQUAL
			B STEP4
NOT_EQUAL
            LDR ONE,=-1
			SUB TMP,EXPONENTX,EXPONENTY
			CMP TMP,#0
			IT LT
			MULLT TMP,ONE
			
			;the exponent of the result is the highest one
			CMP EXPONENTX,EXPONENTY
			BLO XLOWEST
			BHI XHIGHEST
			
XLOWEST
			LSR MANTISSAX,TMP
            MOV EXPONENTX,EXPONENTY
			B STEP4
XHIGHEST
			LSR MANTISSAY,TMP
			B STEP4
STEP4
			ADD TMP,MANTISSAX,MANTISSAY
			LSR TMP1,TMP,#24
			AND TMP1,TMP1,#1
			CMP TMP1,#1
			ITT EQ
			LSREQ TMP,#1
			ADDEQ EXPONENTX,#1
			
			LDR ONE,=0xFF7FFFFF
			AND TMP,ONE
			
			LSL EXPONENTX,#23
			ORR TMP,EXPONENTX
			
			MOV R0,TMP
			
			
	        POP{R4-R8,R10-R11,PC}
			ENDP
			END
				
					
	